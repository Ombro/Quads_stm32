# Keil uVision project Quads_uCOS-II.uvprojx, settings and files
target Quads_uCOS-II (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Quads_uCOS-II
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\CMSIS;.\FWLIB\inc;.\FWLIB\src;.\STARTCODE;.\USER;.\APP;.\BSP;.\uCOS_Port;.\uCOS_Sources;.\implements
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group APP
    ./APP/: app.c app.h os_cfg.h app_cfg.h mpu9250.c mpu9250.h battery.c battery.h motor.c motor.h
  group BSP
    ./BSP/: BSP.c BSP.h
  group USER
    ./USER/: main.c stm32f10x_conf.h stm32f10x_it.h includes.h Global_Variable_Struct.h definition.h Global_Variable_Struct.c stm32f10x_it.c
  group implements
    ./implements/: iic.c iic.h delay.c delay.h kalman.c kalman.h debug.c debug.h usart.c usart.h
  group STARTCODE
    ./STARTCODE/: startup_stm32f10x_hd.s
  group CMSIS
    ./CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLIB
    ./FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group uCOS_Port
    ./uCOS_Port/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group uCOS_Sources
    ./uCOS_Sources/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
  group README
    ./: readme.txt
